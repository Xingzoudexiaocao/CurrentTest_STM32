# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB_Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB_Nucleo +hex
  AfterMake: fromelf.exe --bin -o./STM32F103RB_Nucleo/STM32F103RB_Nucleo.bin ./STM32F103RB_Nucleo/STM32F103RB_Nucleo.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG
  c misc: --C99 --locale=english
  c include: ../Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/STM32F1xx_HAL_Driver/Inc;..\Drivers\BSP\STM32F1xx_Nucleo;..\Drivers\BSP\Adafruit_Shield;..\Drivers\BSP\Components\Common;../Src/FATFS;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lv_examples\lv_tests\lv_test_theme;..\GUI\lv_examples\lv_tests\lv_test_objx\lv_test_btn;..\GUI\lv_examples\lv_tests\lv_test_objx\lv_test_gauge;..\APP;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CustomHID\Inc;..\Middlewares\Third_Party\FreeRTOS\Source\include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group Example/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c Flash.c KeyBoard_Drv.c LED.c SceneHome.c system.c system_stm32f1xx.c delay.c ADS1259.c AD_spi.c lcd.c usbd_conf.c usbd_desc.c usbd_customhid_if.c stm32f1xx_hal_timebase_tim.c UpdataApp.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
  group APP
    ../APP/: UI.c pg_ct.c
  group lv_core
    ../GUI/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../GUI/lvgl/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
  group lv_hal
    ../GUI/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../GUI/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c
  group lv_objx
    ../GUI/lvgl/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../GUI/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_font
    ../GUI/lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_myfont_16.c lv_font_myfont_20.c lv_font_myfont_86.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_examples
    ../GUI/lv_examples/lv_tests/lv_test_theme/: lv_test_theme.c
    ../GUI/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../GUI/lv_examples/lv_tests/lv_test_objx/lv_test_btn/: lv_test_btn.c
    ../GUI/lv_examples/lv_tests/lv_test_objx/lv_test_gauge/: lv_test_gauge.c
    ../GUI/lv_examples/lv_image/: bg.c bg6.c choose.c cloudbg.c cloudbg2.c CO2.c home.c icon.c pm.c QRcode.c sheshidu.c shidu.c sit.c sitai.c voc.c wendu.c
  group USB_Core
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_Class
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_CMSIS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 5.1.2
